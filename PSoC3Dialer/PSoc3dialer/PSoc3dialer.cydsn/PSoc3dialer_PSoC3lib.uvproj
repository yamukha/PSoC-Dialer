# Keil uVision project PSoc3dialer_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3866AXI-040ES2 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: PSoc3dialer_PSoC3lib (library)
  c flags: Optimize=2
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU CASE
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h ADC_DelSig_1.c ADC_DelSig_1.h ADC_DelSig_1_PM.c ADC_DelSig_1_INT.c LED1.c LED1.h LED1_aliases.h LED2.c LED2.h LED2_aliases.h LED3.c LED3.h LED3_aliases.h DTMFHI.c DTMFHI.h DTMFHI_aliases.h DTMFLO.c DTMFLO.h DTMFLO_aliases.h LCD_Char_1.c LCD_Char_1.h LCD_Char_1_PM.c PWM_1.c PWM_1.h PWM_1_PM.c PWM_2.c PWM_2.h PWM_2_PM.c Clock_1.c Clock_1.h Clock_2.c Clock_2.h ADC_DelSig_1_Ext_CP_Clk.c ADC_DelSig_1_Ext_CP_Clk.h ADC_DelSig_1_theACLK.c ADC_DelSig_1_theACLK.h LCD_Char_1_LCDPort_aliases.h LCD_Char_1_LCDPort.c LCD_Char_1_LCDPort.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h Audio_aliases.h ADC_DelSig_1_AMux.c ADC_DelSig_1_AMux.h
target Release (MCS-51)
  device: CY8C3866AXI-040ES2 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: PSoc3dialer_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU CASE
